** sch_path: sim_results/triangular_2x1/tb_2x1_triang_rew_at_neuron.sch
**.subckt tb_2x1_triang_rew_at_neuron
Xx1 net3 VDD j1 vlk GND net8 ul_tun_final W_LEAK=1 CM=0.8p
Xx2 net2 VDD j2 vlk GND net9 ul_tun_final W_LEAK=1 CM=0.8p
Xx3 net1 VDD k1 vr GND net10 ul_tun_final W_LEAK=1 CM=1p
x6 VDD hx net4 GND integrator
XM1 net4 k1 GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
E1 x GND VOL=' 0.800+0.254648*sin(2*3.1416*1*time/0.005)-0.127324*sin(2*3.1416*2*time/0.005)+0.084882*sin(2*3.1416*3*time/0.005)-0.063662*sin(2*3.1416*4*time/0.005)+0.051000*sin(2*3.1416*5*time/0.005)-0.042441*sin(2*3.1416*6*time/0.005)+0.036378*sin(2*3.1416*7*time/0.005)-0.031831*sin(2*3.1416*8*time/0.005)+0.028294*sin(2*3.1416*9*time/0.005)-0.025465*sin(2*3.1416*10*time/0.005) '
x7 VDD vr net5 hx GND opamp_mini
x8 VDD net6 GND x net5 net7 sw
Vin1 net6 GND PWL(0 1.8 19.9m 1.8 20m 0)
Vin9 net7 GND 0.75
XM2 vlk vlk GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
I1 VDD vlk 10nA
G1 VDD net3 x GND cur='max(0, 235.29e-9 * (V(vin) - 0.4))'
G2 VDD net2 x GND cur='max(0, 235.29e-9 * (1.25 - V(vin)))'
Vin2 VDD GND 1.8
xstdp1 VDD GND j1 k1 net1 net8 net10 stdp
xstdp2 VDD GND j2 k1 net1 net9 net10 stdp
**** begin user architecture code

*MADE BY JORGE ALEJANDRO JUAREZ LORA IPN

.subckt rram_v0 TE BE
*N1 TE BE rram_v0_model gap_initial=unif(0.9,0.79)
N1 TE BE rram_v0_model
.ends rram_v0

.model rram_v0_model rram_v0_va


.control

pre_osdi /foss/designs/SNN_IPN/memristor_models/wellposed/rram_v0.osdi
.endc




.param mc_mm_switch=0
.param mc_pr_switch=0
.include /foss/pdks/sky130A/libs.tech/ngspice/corners/tt.spice
.include /foss/pdks/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical.spice
.include /foss/pdks/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical__lin.spice
*.include /foss/pdks/sky130A/libs.tech/ngspice/corners/tt/specialized_cells.spice


**** end user architecture code
**.ends
.GLOBAL VDD
.GLOBAL GND
**** begin user architecture code



.options method gear
.options KLU
.options noinit
.options set num_threads=8
.options set ng_nomodcheck
.options set skywaterpdk
.options set wr_vecnames
.options set wr_singlescale
.options numdgt = 2
.save vr hx x vlk   J1 J2 K1

.tran 1n 1m uic
.control
	run
	write /home/alex/Desktop/EDA/SNN_IPN/sim_results/triangular_2x1/data.raw
.endc



**** end user architecture code
.end
