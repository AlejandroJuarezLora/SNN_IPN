** sch_path: sim_results/automatizator/mnist/layer_input.sch
**.subckt layer_input avdd avss vin1 vin2 vin3 vin4 vin5 vin6 vin7 vin8 vin9 vout1 vout2 vout3 vout4
*+ vout5 vout6 vout7 vout8 vout9 vout10 vout11 vout12 vout13 vout14 vout15
*.iopin avdd
*.iopin avss
*.iopin vin1
*.iopin vin2
*.iopin vin3
*.iopin vin4
*.iopin vin5
*.iopin vin6
*.iopin vin7
*.iopin vin8
*.iopin vin9
*.opin vout1
*.opin vout2
*.opin vout3
*.opin vout4
*.opin vout5
*.opin vout6
*.opin vout7
*.opin vout8
*.opin vout9
*.opin vout10
*.opin vout11
*.opin vout12
*.opin vout13
*.opin vout14
*.opin vout15
Xx1 net1 avdd vout1 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G1 avdd net1 vin1 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx2 net2 avdd vout2 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G2 avdd net2 vin1 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx3 net3 avdd vout3 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G3 avdd net3 vin2 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx4 net4 avdd vout4 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G4 avdd net4 vin2 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx5 net5 avdd vout5 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G5 avdd net5 vin3 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx6 net6 avdd vout6 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G6 avdd net6 vin3 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx7 net7 avdd vout7 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G7 avdd net7 vin4 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx8 net8 avdd vout8 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G8 avdd net8 vin4 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx9 net9 avdd vout9 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G9 avdd net9 vin5 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx10 net10 avdd vout10 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G10 avdd net10 vin5 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx11 net11 avdd vout11 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G11 avdd net11 vin6 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx12 net12 avdd vout12 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G12 avdd net12 vin6 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx13 net13 avdd vout13 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G13 avdd net13 vin7 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx14 net14 avdd vout14 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G14 avdd net14 vin7 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx15 net15 avdd vout15 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G15 avdd net15 vin8 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx16 net16 avdd net19 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G16 avdd net16 vin8 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx17 net17 avdd net20 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G17 avdd net17 vin9 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
Xx18 net18 avdd net21 vlk avss ul_tun_final W_LEAK=1 CM=0.8p
G18 avdd net18 vin9 avss cur='max(1e-9, 235.29e-9 * (V(vin1) - 0.4))'
**.ends

* expanding   symbol:  /foss/designs/SNN_IPN/Neuron/ultralif_final/ul_tun_final.sym # of pins=5
** sym_path: Neuron/ultralif_final/ul_tun_final.sym
** sch_path: Neuron/ultralif_final/ul_tun_final.sch
.subckt ul_tun_final Iext vdd vout Vleak vss  W_LEAK=1 CM=1p
*.iopin Iext
*.iopin vout
*.iopin vss
*.iopin Vleak
*.iopin vdd
XM1 vout vout vm vdd sky130_fd_pr__pfet_01v8 L=10 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout net1 vm vdd sky130_fd_pr__pfet_01v8 L=0.15 W=1.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 net1 net1 vm vdd sky130_fd_pr__pfet_01v8 L=0.15 W=15 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 net1 vout vss vss sky130_fd_pr__nfet_01v8 L=5 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
C1 vm vss @CM m=1
XM9 net2 vout Iext vdd sky130_fd_pr__pfet_01v8 L=0.15 W=4 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
**** begin user architecture code


.save i(vext) v(vout) v(vm)


**** end user architecture code
XM11 vout Vleak vss vss sky130_fd_pr__nfet_01v8 L=0.15 W=@W_LEAK nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM10 net2 vout_n Iext vss sky130_fd_pr__nfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
vext net2 vm 0
XM5 vout_n vout vss vss sky130_fd_pr__nfet_01v8 L=5 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 vout_n vout vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends

.end
