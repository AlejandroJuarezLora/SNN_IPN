** sch_path: tb_4x8x4_openloop.sch
**.subckt tb_4x8x4_openloop
Vdd VDD GND 1.8
x1 VDD GND in N1 N2 N3 N4 layer_input
x4 VDD net7 GND net6 net5 J1 J2 net4 J3 net3 J4 net2 J5 net1 J6 J7 net12 J8 layer_hidden
x5 VDD net7 net6 net5 GND J1 J2 net1 net12 net3 J3 net4 net2 J8 J7 J6 J5 J4 N1 N2 N3 N4 no_stdp_4x8
x6 net9 net8 M2 net10 GND M1 M3 net11 M4 J1 J2 J3 J4 J5 J6 J7 J8 VDD stdp_8x4
Vin1 in net14 0.75
Vin4 net14 net15 SINE(0 -0.44563 500 0 0)
Vin5 net15 net16 SINE(0 -0.1485 1500 0 0)
Vin6 net16 net17 SINE(0 -0.0891 2500 0 0)
Vin7 net17 net18 SINE(0 -0.0636 3500 0 0)
Vin8 net18 GND SINE(0 -0.0495 4500 0 0)
x7 VDD ctrl GND in x net13 sw
Vin3 ctrl GND PWL(0 1.8 19.9m 1.8 20m 0)
Vin9 net13 GND 0.75
x2 VDD net8 GND net9 net10 hx net11 M1 M2 M3 M4 layer_output_no_rew
**** begin user architecture code

*MADE BY JORGE ALEJANDRO JUAREZ LORA IPN

.subckt rram_v0 TE BE
*N1 TE BE rram_v0_model gap_initial=unif(0.9,0.79)
N1 TE BE rram_v0_model gap_initial=0.9
.ends rram_v0

.model rram_v0_model rram_v0_va


.control

pre_osdi /foss/designs/SNN_IPN/memristor_models/wellposed/rram_v0.osdi
.endc




.param mc_mm_switch=0
.param mc_pr_switch=0
.include /foss/pdks/sky130A/libs.tech/ngspice/corners/tt.spice
.include /foss/pdks/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical.spice
.include /foss/pdks/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical__lin.spice
*.include /foss/pdks/sky130A/libs.tech/ngspice/corners/tt/specialized_cells.spice


**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
**** begin user architecture code



.options method gear
.options KLU
.options noinit
.options set num_threads=4
.options set ng_nomodcheck
.options set skywaterpdk
.options set wr_vecnames
.options set wr_singlescale
.options numdgt = 2
.save in Vr1 I(Vread) hx x ctrl  N1 N2 N3 N4 M1 M2 M3 M4 J1 J2 J3 J4 J5 J6 J7 J8

.tran 25n 25m
*.control
*	run
*	write /home/alex/Desktop/EDA/SNN_IPN/sim_results/data.raw
*.endc


**** end user architecture code
.end
