** sch_path: tb_bp.sch
**.subckt tb_bp
V1 VDD GND 1.8
x6 VDD Iin vbp_in net1 GND net4 ultralif
XM19 net1 net1 GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
I3 VDD net1 10n
In VDD net2 90n
x2 VDD net2 vbp_in net1 GND net4 ultralif
In2 VDD Iin 30n
x5 VDD net5 vout_post net1 GND net4 ultralif
x3 WP=19.5k Xr=150 C=200p K=50 Qp='1.414*WP' C2=0.5nF C3='C*(Xr - 2*Qp - ((Xr*Xr-4*(Qp**2)*Xr)**(0.5))/(2*(Qp**2)))'
+ R='1/(Qp*WP*(C2+C3))' R2='Xr*R' R1='C2*R2/(K*(C2+C3))' Rm='(C2*R*R2)/(C2*R2-(R*K*(C2+C3)))'
?1 VDD vbp_in net3 GND
bpfilter

In1 VDD net3 20n
XM7 net4 net4 VDD VDD sky130_fd_pr__pfet_01v8 L=0.15 W=2 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
In3 net4 GND 100n
Vin_post net3 net5 0
**** begin user architecture code
.lib $::SKYWATER_MODELS/sky130.lib.spice tt
**** end user architecture code
**.ends
.GLOBAL VDD
.GLOBAL GND
**** begin user architecture code


.options save all
.tran 10n 50u uic
.control
	run
	write tb_bp.raw
.endc


**** end user architecture code
.end
