** sch_path: tb_bp.sch
**.subckt tb_bp
x9 WP=19.5k Xr=150 C=200p K=50 Qp='1.414*WP' C2='C' C3='C*(Xr - 2*Qp - ((Xr*Xr-4*(Qp**2)*Xr)**(0.5))/(2*(Qp**2)))'
+ R='1/(Qp*WP*(C2+C3))' R2='Xr*R' R1='C2*R2/(K*(C2+C3))' Rm='(C2*R*R2)/(C2*R2-(R*K*(C2+C3)))'
?1 VDD net1 vout GND
bpfilter

V1 VDD GND 1.8
V2 net1 GND SINE(0.9 0.9 100k 0 0 0)
**** begin user architecture code
.lib $::SKYWATER_MODELS/sky130.lib.spice tt
**** end user architecture code
**.ends
.GLOBAL VDD
.GLOBAL GND
**** begin user architecture code


.options savecurrents
.tran 100n 2m uic
.control
	run
	write tb_bp.raw
.endc


**** end user architecture code
.end
