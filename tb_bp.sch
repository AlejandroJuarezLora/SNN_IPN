** sch_path: tb_bp.sch
**.subckt tb_bp
V1 VDD GND 1.8
x6 VDD Iin vout_1 net1 GND ultralif
XM19 net1 net1 GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
I3 VDD net1 10n
In VDD Iin 150n
x2 VDD net2 vout_2 net1 GND ultralif
In2 VDD net2 50n
x1 VDD vout_1 vbp_pre GND syn_rep
x3 VDD vout_2 vbp_pre GND syn_rep
x5 VDD vbp_post vout_post net1 GND ultralif
x4 WP=19.5k Xr=150 C=200p K=50 Qp='1.414*WP' C2=100nF C3='C*(Xr - 2*Qp - ((Xr*Xr-4*(Qp**2)*Xr)**(0.5))/(2*(Qp**2)))'
+ R='1/(Qp*WP*(C2+C3))' R2='Xr*R' R1='C2*R2/(K*(C2+C3))' Rm='(C2*R*R2)/(C2*R2-(R*K*(C2+C3)))'
?1 VDD vbp_pre vbp_post GND
bpfilter

**** begin user architecture code
.lib $::SKYWATER_MODELS/sky130.lib.spice tt
**** end user architecture code
**.ends
.GLOBAL VDD
.GLOBAL GND
**** begin user architecture code


*.options savecurrents
.tran 50n 100u uic
.control
	run
	write tb_bp.raw
.endc


**** end user architecture code
.end
