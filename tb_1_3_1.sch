** sch_path: tb_1_3_1.sch
**.subckt tb_1_3_1
V1 VDD GND 1.8
x6 VDD vin_j_1 vout_j_1 net1 GND ultralif
x7 VDD vin_k_1 vout_k_1 net1 GND ultralif
XM19 net1 net1 GND GND sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
I3 VDD net1 10n
x1 VDD VDD GND vout_j_1 vout_k_1 rstdp_switched
x2 VDD vin_j_2 vout_j_2 net1 GND ultralif
x3 VDD VDD GND vout_j_2 vout_k_1 rstdp_switched
x4 VDD vin_j_3 vout_j_3 net1 GND ultralif
x5 VDD VDD GND vout_j_3 vout_k_1 rstdp_switched
In3 VDD vin_k_1 25n
x8 VDD vin_i_1 vout_i_1 net1 GND ultralif
In1 VDD vin_i_1 SINE(90n 90n 100k 0 0 0)
x9 WP=19.5k Xr=150 C=200p K=50 Qp='1.414*WP' C2='C' C3='C*(Xr - 2*Qp - ((Xr*Xr-4*(Qp**2)*Xr)**(0.5))/(2*(Qp**2)))'
+ R='1/(Qp*WP*(C2+C3))' R2='Xr*R' R1='C2*R2/(K*(C2+C3))' Rm='(C2*R*R2)/(C2*R2-(R*K*(C2+C3)))'
?1 VDD vout_i_1 vin_j_1 GND
bpfilter

x10 WP=19.5k Xr=150 C=200p K=50 Qp='1.414*WP' C2='C' C3='C*(Xr - 2*Qp - ((Xr*Xr-4*(Qp**2)*Xr)**(0.5))/(2*(Qp**2)))'
+ R='1/(Qp*WP*(C2+C3))' R2='Xr*R' R1='C2*R2/(K*(C2+C3))' Rm='(C2*R*R2)/(C2*R2-(R*K*(C2+C3)))'
?1 VDD vout_i_1 vin_j_2 GND
bpfilter

x11 WP=19.5k Xr=150 C=200p K=50 Qp='1.414*WP' C2='C' C3='C*(Xr - 2*Qp - ((Xr*Xr-4*(Qp**2)*Xr)**(0.5))/(2*(Qp**2)))'
+ R='1/(Qp*WP*(C2+C3))' R2='Xr*R' R1='C2*R2/(K*(C2+C3))' Rm='(C2*R*R2)/(C2*R2-(R*K*(C2+C3)))'
?1 VDD vout_i_1 vin_j_3 GND
bpfilter

In2 VDD vin_j_1 25n
In4 VDD vin_j_2 25n
In5 VDD vin_j_3 25n
**** begin user architecture code
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

** opencircuitdesign pdks install
.inc $::SKYWATER_MODELS/rram_v0.spice

**** end user architecture code
**.ends
.GLOBAL VDD
.GLOBAL GND
**** begin user architecture code


.options savecurrents
.tran 100n 1m uic
.control
	run
	write tb_1_3_1.raw
.endc


**** end user architecture code
.end
